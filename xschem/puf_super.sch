v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 3580 -280 0 0 {name=p1 lab=reset}
C {devices/iopin.sym} 3580 -250 0 0 {name=p2 lab=clk}
C {devices/iopin.sym} 3580 -220 0 0 {name=p3 lab=puf_sel1}
C {devices/iopin.sym} 3580 -190 0 0 {name=p4 lab=puf_sel0}
C {devices/iopin.sym} 3580 -160 0 0 {name=p5 lab=length1}
C {devices/iopin.sym} 3580 -130 0 0 {name=p6 lab=length0}
C {devices/iopin.sym} 3580 -100 0 0 {name=p7 lab=out}
C {devices/iopin.sym} 3580 -70 0 0 {name=p8 lab=so}
C {devices/iopin.sym} 3580 -40 0 0 {name=p9 lab=vccd1}
C {devices/iopin.sym} 3580 -10 0 0 {name=p10 lab=rstn}
C {devices/iopin.sym} 3580 20 0 0 {name=p11 lab=vssd1}
C {devices/iopin.sym} 3580 50 0 0 {name=p12 lab=si}
